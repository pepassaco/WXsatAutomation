options:
  parameters:
    author: pepassaco
    category: Custom
    description: v4
    generate_options: no_gui
    id: WXsat_LRPT
    output_language: python
    title: Desmodulador QPSK
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"RX"'
  states: {}
- name: debug
  id: variable
  parameters:
    value: '"/src/Resultados/Meteor/Meteor_d"+ datetime.now().strftime("%d%m%Y_%H%M")+"_D"'
  states: {}
- name: f_real
  id: variable
  parameters:
    value: '1'
  states: {}
- name: lp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '55000'
    gain: '1.0'
    samp_rate: samp_rate_airspy
    width: '5000'
    win: firdes.WIN_HAMMING
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(filterSize, filterSize, 1.0/float(sps), 0.6, 45*filterSize)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_airspy/decim
  states: {}
- name: sps
  id: variable
  parameters:
    value: (samp_rate*1.0)/(symb_rate*1.0)
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '400000'
    rate: '1e-2'
    reference: '1.2'
    type: complex
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq*(1-f_real)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_airspy
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: arg_airspy
  id: parameter
  parameters:
    label: Parámetros de conexión del soapySDR
    type: str
    value: '"remote=192.168.0.10:55132, remote:driver=airspyhf"'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: salida
    type: byte
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: debug
    type: complex
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '127'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 5/4
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.707'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.4142'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: decim
  id: parameter
  parameters:
    label: Factor de diezmado
    type: eng_float
    value: '1'
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: eqGain
    num_taps: '16'
    sps: '1'
  states: {}
- name: digital_constellation_soft_decoder_cf_1
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: digital.constellation_calcdist(([-1-1j, -1+1j, 1+1j, 1-1j]), ([0, 1, 3, 2]), 4, 1).base()
  states: {}
- name: digital_costas_loop_cc_1_0_1
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: pll_alpha
  states: {}
- name: digital_symbol_sync_xx_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '0.7'
    loop_bw: loopBW
    max_dev: '0.01'
    nfilters: filterSize
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: doppler_MsgPairToVar_0
  id: doppler_MsgPairToVar
  parameters:
    target: f_real
  states: {}
- name: doppler_doppler_0
  id: doppler_doppler
  parameters:
    gnd_alt: '666'
    gnd_lat: '40.4167'
    gnd_lon: '-3.70325'
    refresh_period: '0.1'
    sat_id: ISS
    tle_file: /src/sample_file
    verbose: 'False'
  states: {}
- name: eqGain
  id: parameter
  parameters:
    label: Ganancia del ecualizador CMA
    value: '0.008'
  states: {}
- name: f_offset
  id: parameter
  parameters:
    label: Offset entre frecuencia de sintonizador y frecuencia de satéltie
    type: eng_float
    value: '200000'
  states: {}
- name: filterSize
  id: parameter
  parameters:
    label: Tamaño del banco de filtros del lazo de Gardner
    type: eng_float
    value: '16'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frecuencia
    type: eng_float
    value: '137100000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-f_offset'
    decim: decim
    samp_rate: samp_rate_airspy
    taps: lp_taps
    type: ccc
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Ganancia de RF del SDR
    value: '30'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: loopBW
  id: parameter
  parameters:
    label: Ancho de banda del lazo de Gardner
    value: '0.0785'
  states: {}
- name: lp_corte
  id: parameter
  parameters:
    label: Frecuencia de corte del filtro paso bajo
    type: eng_float
    value: '60000'
  states: {}
- name: pll_alpha
  id: parameter
  parameters:
    label: Ancho de banda del Bucle de Costas
    value: '0.02'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    color1: '"dark green"'
    gui_hint: tabs@1
    label1: Output constellation
    marker1: '3'
    size: '4096'
    type: complex
    update_time: 4096/symb_rate
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"red"'
    fc: '0'
    fftsize: '4096'
    gui_hint: tabs@0
    label1: Trasladada y filtrada
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: tabs@0
    label1: Original
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    size: '256'
    srate: samp_rate
    type: float
    update_time: '0.5'
  states: {state: disabled}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.6'
    decim: '1'
    gain: '1'
    ntaps: '64'
    samp_rate: samp_rate
    sym_rate: symb_rate
    type: fir_filter_ccf
  states: {}
- name: salida
  id: parameter
  parameters:
    label: Fichero de salida
    type: str
    value: '"/src/Resultados/Pruebas/conEQ.s"'
  states: {}
- name: samp_rate_airspy
  id: parameter
  parameters:
    label: Tasa de muestreo
    type: eng_float
    value: '768000'
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: antenna
    args: arg_airspy
    balance0: '0'
    center_freq0: freq+f_offset
    comment: |-
      Use SoapySDRServer --bind="0.0.0.0:1234"
      or similar to the remote server
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dev: driver=remote
    devname: custom
    overall_gain0: gain
    samp_rate: samp_rate_airspy
    sdrplay_biastee: 'True'
    type: fc32
  states: {}
- name: symb_rate
  id: parameter
  parameters:
    label: Tasa de símbolos
    type: eng_float
    value: '72000'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: FFT
    label1: Constellation
    num_tabs: '2'
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_char_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_char_0, '0', blocks_null_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_costas_loop_cc_1_0_1, '0']
- [blocks_multiply_const_vxx_1, '0', analog_rail_ff_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', digital_constellation_soft_decoder_cf_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_const_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', analog_agc_xx_0, '0']
- [digital_cma_equalizer_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_soft_decoder_cf_1, '0', blocks_multiply_const_vxx_1, '0']
- [digital_costas_loop_cc_1_0_1, '0', blocks_multiply_const_vxx_1_0, '0']
- [digital_symbol_sync_xx_0_0_0, '0', digital_cma_equalizer_cc_0, '0']
- [doppler_doppler_0, dop_factor, doppler_MsgPairToVar_0, inpair]
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', digital_symbol_sync_xx_0_0_0, '0']
- [soapy_source_0, '0', blocks_file_sink_2, '0']
- [soapy_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
