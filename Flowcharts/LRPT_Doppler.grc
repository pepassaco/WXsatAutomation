options:
  parameters:
    author: pepassaco
    category: Custom
    generate_options: qt_gui
    id: WXsat_LRPT
    output_language: python
    title: Desmodulador QPSK
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"RX"'
  states: {}
- name: bitstream_name
  id: variable
  parameters:
    value: '"/home/otti/meteor_LRPT_" + datetime.now().strftime("%d%m%Y_%H%M") + ".s"'
  states: {}
- name: clock_alpha
  id: variable_qtgui_range
  parameters:
    label: Clock Alpha
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '0.01'
    value: '0.001'
    widget: slider
  states: {}
- name: decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: f_real
  id: variable
  parameters:
    value: freq
  states: {}
- name: freq
  id: variable
  parameters:
    value: '137100000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '40'
    value: '30'
  states: {}
- name: pll_alpha
  id: variable_qtgui_range
  parameters:
    label: PLL Alpha
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '0.1'
    value: '0.015'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_airspy/decim
  states: {}
- name: samp_rate_airspy
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: (samp_rate*1.0)/(symb_rate*1.0)
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: '72000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '4000'
    rate: '1000e-4'
    reference: '0.5'
    type: complex
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq-f_real
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_airspy
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: bitstream_name
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '127'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: clock_alpha
    gain_omega: clock_alpha**2/4.0
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_constellation_soft_decoder_cf_1
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: digital.constellation_calcdist(([-1-1j, -1+1j, 1+1j, 1-1j]), ([0, 1, 3, 2]), 4, 1).base()
  states: {}
- name: digital_costas_loop_cc_1
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: pll_alpha
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: f_real
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: '7356'
    verbose: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.6'
    decim: '1'
    gain: '1'
    ntaps: '361'
    samp_rate: samp_rate
    sym_rate: symb_rate
    type: fir_filter_ccf
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: antenna
    args: '"remote=192.168.0.10:55132, remote:driver=airspyhf"'
    balance0: '0'
    center_freq0: freq
    comment: |-
      Use SoapySDRServer --bind="0.0.0.0:1234"
      or similar to the remote server
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dev: driver=remote
    devname: custom
    overall_gain0: gain
    samp_rate: samp_rate_airspy
    sdrplay_biastee: 'True'
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_char_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_char_0, '0', blocks_null_sink_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_constellation_soft_decoder_cf_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_soft_decoder_cf_1, '0', analog_rail_ff_0, '0']
- [digital_costas_loop_cc_1, '0', digital_clock_recovery_mm_xx_0, '0']
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [rational_resampler_xxx_0, '0', analog_agc_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_costas_loop_cc_1, '0']
- [soapy_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
