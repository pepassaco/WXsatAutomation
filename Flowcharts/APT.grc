options:
  parameters:
    author: pepassaco
    category: Custom
    generate_options: qt_gui
    id: WXsat_APT
    output_language: python
    title: Desmodulador FM para NOAA
  states: {}

blocks:
- name: af_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,4,1,1
    label: Volumen audio
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '5'
    stop: '60'
    value: '30'
    widget: dial
  states: {}
- name: antenna
  id: variable
  parameters:
    value: '"RX"'
  states: {}
- name: bpf_hp
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@2
    label: Band Pass Filter Hp
    min_len: '100'
    orient: Qt.Horizontal
    start: '800'
    step: '10'
    stop: '8000'
    value: '5000'
  states: {}
- name: bpf_lp
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@2
    label: Band Pass Filter Lp
    min_len: '100'
    orient: Qt.Horizontal
    start: '200'
    step: '10'
    stop: '500'
    value: '500'
  states: {}
- name: cutoff
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Frecuencia de corte LPF (kHz)
    orient: Qt.Horizontal
    start: '10'
    step: '1'
    stop: '48'
    value: '40'
  states: {}
- name: f_real
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fcd_freq
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,1, 1,2
    label: Seleccionar Satelite
    label0: NOAA 15
    label1: NOAA 18
    label2: NOAA 19
    label3: Oceano FM
    num_opts: '4'
    option0: '137620000'
    option1: '137912500'
    option2: '137100000'
    option3: '93900000'
    orient: Qt.QHBoxLayout
    type: int
    value: '137100000'
    widget: radio_buttons
  states: {}
- name: lna_gain_0
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,4,1,1
    label: Ganancia SDR (dB)
    label0: 0 dB
    label1: + 10 dB
    label2: + 20 dB
    label3: + 30 dB
    label4: + 35 dB
    num_opts: '5'
    option0: '0'
    option1: '10'
    option2: '20'
    option3: '30'
    option4: '35'
    type: int
    value: '30'
  states: {}
- name: prefix
  id: variable
  parameters:
    value: '"/home/tallerine/sdr-apt/wav/"'
  states: {}
- name: recfile
  id: variable
  parameters:
    value: '"/src/prueba1.wav"'
  states: {}
- name: recfile2
  id: variable
  parameters:
    value: '"/src/prueba2.wav"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,3,1,1
    label: Frecuencia Portadora
    type: real
    value: fcd_freq
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fcd_freq*(1-f_real)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    comment: Demodulación FM
    quad_rate: '96000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: bpf_hp
    interp: '1'
    low_cutoff_freq: bpf_lp
    samp_rate: '48000'
    type: interp_fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '5'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '11'
    max_iter: '4000'
    scale: 1/11.
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: af_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    comment: Registro de archivo de audio
    file: recfile
    samp_rate: '20800'
  states: {}
- name: blocks_wavfile_sink_1_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: recfile2
    samp_rate: '4160'
  states: {}
- name: doppler_MsgPairToVar_0
  id: doppler_MsgPairToVar
  parameters:
    target: freq_real
  states: {}
- name: doppler_doppler_0
  id: doppler_doppler
  parameters:
    gnd_alt: '666'
    gnd_lat: '40.4167'
    gnd_lon: '-3.70325'
    refresh_period: '0.1'
    sat_id: ISS
    tle_file: ''
    verbose: 'False'
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: '5'
    win: firdes.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2000'
    decim: '1'
    gain: '10'
    samp_rate: '20800'
    type: fir_filter_fff
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff*1000
    decim: '1'
    gain: '30'
    samp_rate: '96000'
    type: fir_filter_ccf
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '96000'
    fc: '0'
    fftsize: '2048'
    gui_hint: tab@0
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '2048'
    gui_hint: tab@1
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: tab@1
    label1: ''
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab@2
    label1: ''
    size: '2080'
    srate: 2080*2
    tr_level: '0.4'
    type: float
    update_time: '.5'
    ymax: '2'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@0
    label1: ''
    label2: ''
    size: '1024'
    srate: '96000'
    type: complex
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '96000'
    fc: '0'
    fftsize: '4096'
    gui_hint: tab@0
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Bajo tasa de muestreo
    decim: samp_rate
    interp: '96000'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    comment: Cambio tasa de muestreo
    decim: '48000'
    interp: '20800'
    taps: ''
    type: fff
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: antenna
    args: '"remote=192.168.0.10:55132, remote:driver=airspyhf"'
    balance0: '0'
    center_freq0: fcd_freq
    comment: |-
      Use SoapySDRServer --bind="0.0.0.0:1234"
      or similar to the remote server
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dev: driver=remote
    devname: custom
    overall_gain0: lna_gain_0
    samp_rate: samp_rate
    sdrplay_biastee: 'True'
    type: fc32
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Senal en recepcion
    label1: Demodulacion FM
    label2: Demodulacion AM
    num_tabs: '3'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_wavfile_sink_0_0, '0']
- [band_pass_filter_0, '0', hilbert_fc_0_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_wavfile_sink_1_0, '0']
- [blocks_keep_one_in_n_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_moving_average_xx_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [doppler_doppler_0, dop_factor, doppler_MsgPairToVar_0, inpair]
- [hilbert_fc_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [low_pass_filter_1_0, '0', analog_wfm_rcv_0_0, '0']
- [low_pass_filter_1_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_1_0, '0', qtgui_time_sink_x_2_0, '0']
- [low_pass_filter_1_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_1_0, '0']
- [rational_resampler_xxx_0_0_0, '0', low_pass_filter_0_0, '0']
- [soapy_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
