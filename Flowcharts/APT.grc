options:
  parameters:
    author: pepassaco
    category: Custom
    generate_options: no_gui
    id: WXsat_APT
    output_language: python
    title: Desmodulador FM para NOAA
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"RX"'
  states: {}
- name: debug
  id: variable
  parameters:
    value: '"/src/Resultados/NOAA/NOAA_"+ datetime.now().strftime("%d%m%Y_%H%M")+"_Raw"'
  states: {}
- name: f_real
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_airspy/decim
  states: {}
- name: af_decim
  id: parameter
  parameters:
    label: Factor de diezmado de la AF
    type: eng_float
    value: '2'
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: af_decim
    comment: Demodulación FM
    quad_rate: samp_rate
  states: {}
- name: arg_airspy
  id: parameter
  parameters:
    label: Parámetros de conexión del soapySDR
    type: str
    value: '"remote=192.168.0.10:55132, remote:driver=airspyhf"'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: bp_h
    interp: '1'
    low_cutoff_freq: bp_l
    samp_rate: samp_rate/af_decim
    type: interp_fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: debug
    type: complex
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    comment: Registro de archivo de audio
    file: recfile
    samp_rate: int(samp_rate/af_decim)
  states: {}
- name: bp_h
  id: parameter
  parameters:
    label: Frecuencia de corte superior del filtro paso banda
    type: eng_float
    value: '5000'
  states: {}
- name: bp_l
  id: parameter
  parameters:
    label: Frecuencia de corte inferior del filtro paso banda
    type: eng_float
    value: '500'
  states: {}
- name: decim
  id: parameter
  parameters:
    label: Factor de diezmado
    type: eng_float
    value: '4'
  states: {}
- name: doppler_MsgPairToVar_0
  id: doppler_MsgPairToVar
  parameters:
    target: f_real
  states: {}
- name: doppler_doppler_0
  id: doppler_doppler
  parameters:
    gnd_alt: '666'
    gnd_lat: '40.4167'
    gnd_lon: '-3.70325'
    refresh_period: '0.1'
    sat_id: ISS
    tle_file: /src/sample_file
    verbose: 'False'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frecuencia
    type: eng_float
    value: '137100000'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Ganancia de RF del SDR
    value: '30'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lp_corte
    decim: decim
    gain: '1'
    samp_rate: samp_rate_airspy
    type: fir_filter_ccf
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: lp_corte
  id: parameter
  parameters:
    label: Frecuencia de corte del filtro paso bajo
    type: eng_float
    value: '60000'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '96000'
    fc: '0'
    fftsize: '2048'
    gui_hint: tab@0
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: samp_rate_airspy
  id: parameter
  parameters:
    label: Tasa de muestreo
    type: eng_float
    value: '768000'
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: antenna
    args: arg_airspy
    balance0: '0'
    center_freq0: freq
    comment: |-
      Use SoapySDRServer --bind="0.0.0.0:1234"
      or similar to the remote server
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dev: driver=remote
    devname: custom
    overall_gain0: gain
    samp_rate: samp_rate_airspy
    sdrplay_biastee: 'True'
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_wavfile_sink_0_0, '0']
- [doppler_doppler_0, dop_factor, doppler_MsgPairToVar_0, inpair]
- [low_pass_filter_1_0, '0', analog_wfm_rcv_0_0, '0']
- [low_pass_filter_1_0, '0', qtgui_freq_sink_x_0_0, '0']
- [soapy_source_0, '0', blocks_file_sink_0, '0']
- [soapy_source_0, '0', low_pass_filter_1_0, '0']

metadata:
  file_format: 1
